# Keil uVision project demo.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32H7B0VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00100000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00020000) XRAM2(0x38000000,0x00008000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32H7B0xx
  c include: ..\..\User\BSP\inc;..\..\Libraries\STM32H7xx_HAL_Driver\Inc;..\..\Libraries\STM32H7xx_HAL_Driver\Inc\Legacy;..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\Libraries\CMSIS\Include;..\..\User;..\..\User\BSP;..\..\User\BSP\inc;..\..\User\bsp_self\inc;..\..\OS;..\..\User\Fonts;..\..\Libraries\CMSIS\DSP\Include;..\..\Libraries\CMSIS\DSP\PrivateInclude;.\RTE\Compiler;..\..\User\gui
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0x30000000 size 0x20000
  memory RVCT7: RAM 0x38000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x100000
  scatter file: .\Objects\demo.sct
  group User
    ../../User/: main.c
  group BSP
    ../../User/: stm32h7xx_it.c
    ../../User/BSP/src/: bsp_lcd.c
    ../../User/BSP/: bsp.c
    ../../User/bsp_self/src/: bsps_adc.c bsps_ui.c bsps_iic.c bsps_touch.c bsps_measure.c bsps_fft.c bsps_ad9288.c bsps_test.c bsps_thread.c bsps_encoder.c bsps_periph.c
  group MDK-ARM
    ./: startup_stm32h7b0xx.s
  group HAL_Driver
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group CMSIS/DSP
    ../../Libraries/CMSIS/DSP/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../../Libraries/CMSIS/DSP/Source/CommonTables/: CommonTables.c
    ../../Libraries/CMSIS/DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c
    ../../Libraries/CMSIS/DSP/Source/ControllerFunctions/: ControllerFunctions.c
    ../../Libraries/CMSIS/DSP/Source/FastMathFunctions/: FastMathFunctions.c
    ../../Libraries/CMSIS/DSP/Source/FilteringFunctions/: FilteringFunctions.c
    ../../Libraries/CMSIS/DSP/Source/MatrixFunctions/: MatrixFunctions.c
    ../../Libraries/CMSIS/DSP/Source/StatisticsFunctions/: StatisticsFunctions.c
    ../../Libraries/CMSIS/DSP/Source/SupportFunctions/: SupportFunctions.c
    ../../Libraries/CMSIS/DSP/Source/TransformFunctions/: TransformFunctions.c
    ../../Libraries/CMSIS/DSP/Source/WindowFunctions/: WindowFunctions.c
  group OS
    ../../OS/: os.c
  group GUI
    ../../User/gui/: gui.c gui_dev.c
  group Fonts
    ../../User/Fonts/: asc12.c asc16.c asc24.c asc32.c hz12.c hz16.c hz24.c hz32.c ra8875_asc_width.c
  group Doc
    ../../Doc/: readme.txt
software components: Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0
